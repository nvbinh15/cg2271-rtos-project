# Keil uVision project Blinky.uvprojx, settings and files
target ULink2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target ULink2 MTB (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
